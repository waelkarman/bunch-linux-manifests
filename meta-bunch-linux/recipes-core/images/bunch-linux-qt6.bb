SUMMARY = "BunchLinux is an embedded OS image where to integrate any possible software"

require bunch-linux-core.inc