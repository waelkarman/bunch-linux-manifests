SUMMARY = "bunch-linux-basic is a basic image to dive into the kernel development."
# see /bunch-linux-manifests/meta-bunch-linux/recipes-dynamic/recipes-core/bunch-linux-basic.bbappend

inherit core-image