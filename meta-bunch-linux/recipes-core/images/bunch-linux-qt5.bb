SUMMARY = "bunch-linux-qt5 is an image that supports Qt6 development"

require bunch-linux-core.inc