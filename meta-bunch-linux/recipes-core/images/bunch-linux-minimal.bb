SUMMARY = "bunch-linux-minimal is a basic image to experiment new feature quickly"

require bunch-linux-core.inc