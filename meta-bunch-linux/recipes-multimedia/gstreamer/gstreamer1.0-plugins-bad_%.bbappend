# Extra plugins on top of the oe-core defaults
PACKAGECONFIG:append = " kms rtmp tinyalsa v4l2codecs"
