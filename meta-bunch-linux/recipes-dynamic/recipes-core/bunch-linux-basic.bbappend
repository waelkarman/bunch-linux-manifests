SUMMARY = "bunch-linux-basic is a basic image to dive into the kernel development."

IMAGE_INSTALL += " hello-module"